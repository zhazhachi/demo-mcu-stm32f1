# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c misc: --cpp11
  c include: .\user;.\user\function;.\lib\system\inc;.\lib\hardware\inc;.\lib\core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: setup.cpp it.c main.cpp
    ./: README.md
  group function
    ./user/function/: function.cpp FCT.cpp Ans.cpp UI.cpp
  group system
    ./lib/system/src/: sys.cpp rcc.cpp std.cpp delay.cpp nvic.cpp gpio.cpp task.cpp adc.cpp dac.cpp dma.cpp exti.cpp flash.cpp map.cpp i2c.cpp pwr.cpp rtc.cpp spi.cpp tim.cpp usart.cpp wdg.cpp crc.cpp
  group hardware
    ./lib/hardware/src/: font.cpp DS18B20.cpp EEPROM.cpp GPS.cpp GSM.cpp MPU6050.cpp InfraRed.cpp touch.cpp lcd.cpp OV7670.cpp SCCB.cpp sdcard.cpp wifi.cpp des.c RFID.cpp LCD12864.cpp ultrasonic.cpp
  group core
    ./lib/core/: startup_stm32f10x_hd.s startup_stm32f10x_md.s core_cm3.c system_stm32f10x.c
